## package/powertune/Config.in
```kconfig
config BR2_PACKAGE_POWERTUNE
        bool "powertune"
        help
          Qt5 ECU Info viewer.

          
```
